Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-08-24T18:54:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 24 18:54:33 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\a0966e0b-436c-4578-948b-8dc13fc44520\641e9f89-ecf1-40fb-a2a5-4c94885aab6d\ifc * Database version: 5507 * Database creation date: Wed Aug 24 18:54:33 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 24 18:54:33 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 24 18:54:33 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12095120_F_DGC7845HCXPro_BRWS:23784558_F_12095120_DGC7845HCXPro_BRWS, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 23784558_F_12095120_DGC7845HCXPro_BRWS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 23784558_F_12095120_DGC7845HCXPro_BRWS
Type - Pset_ProvisionForVoid - Depth: 569 mm
Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_IN, z_Miele_Connection_Water_OUT, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm

# IfcDistributionPort, Port_353505
Description: Flow; FlowDirection: SOURCEANDSINK
